Commit message: fix arm_stability

File: urdf/arm_assem_urdf_v3.urdf (robot description, URDF)
Before this commit: robot arm_assem_urdf_v3, 10 links, 9 joints
Links:
- added link world
Joints:
- added joint base_joint: type fixed, parent world, child base_link, origin xyz=0.0 0.0 0.0 rpy=0 0 0
